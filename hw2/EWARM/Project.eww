<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\xln_hw2.ewp</path>
  </project>
  <batchBuild />
</workspace>
